options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: tx_stage3
    output_language: python
  states: {}

blocks:
- name: bps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '''10101010111101010101111111111111111111111'''
    bps: bps
    threshold: thresh
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '3'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '2000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '2'
    minsize: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '10000'
    type: complex
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {state: bypassed}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_1, in]
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [digital_crc32_async_bb_1, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, blocks_message_debug_0, print_pdu]
- [digital_protocol_formatter_async_0, payload, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
