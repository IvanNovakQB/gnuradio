options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_packet_tx
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {state: disabled}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.9'
    value: '0.5'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: 1500*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc_hdr
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 500e3
    stop: 3e9
    value: 483e6-300
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '83'
    value: '50'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: digital.packet_utils.default_access_code
    bps: '1'
    threshold: '3'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: len(tx_rrc_taps)
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    orient: Qt.Horizontal
    start: 200e3
    step: 200e3
    stop: 10e6
    value: 1000e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '150'
    minsize: '15'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: packet_len
    type: complex
  states: {state: disabled}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab0@2
    legend: 'False'
    size: '1024'
    tr_tag: packet_len
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab0@1
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab0@0
    label1: ''
    label2: ''
    legend: 'False'
    size: '2500'
    srate: '1'
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: uhd.tune_request(freq, samp_rate/2.0)
    clock_rate: '0.0'
    clock_source0: gpsdo
    dev_args: '"addr=1d50:6108,driver=lime,media=''USB 3.0'',module=FX3,name=LimeSDR-USB,serial=0009081C05C21A36,type=soapy,uhd"'
    gain0: gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', blocks_tag_debug_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_random_pdu_0, pdus, packet_tx_0, in]
- [packet_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [packet_tx_0, postcrc, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
