options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: zmq_msg
    output_language: python
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '100'
    msg: pmt.intern("TEST")
    std: '0'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    key: ivana
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    key: '9'
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {state: disabled}
- name: zeromq_rep_msg_sink_0
  id: zeromq_rep_msg_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {state: disabled}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    key: ivana
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {state: disabled}

connections:
- [blocks_message_strobe_random_0, strobe, zeromq_pub_msg_sink_0, in]
- [blocks_message_strobe_random_0, strobe, zeromq_pub_msg_sink_0_0, in]
- [blocks_message_strobe_random_0, strobe, zeromq_push_msg_sink_0, in]
- [blocks_message_strobe_random_0, strobe, zeromq_rep_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_req_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
